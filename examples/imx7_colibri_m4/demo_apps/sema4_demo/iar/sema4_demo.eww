<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>sema4_demo</project><configuration>Release</configuration></member><member><project>sema4_demo</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>sema4_demo</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>sema4_demo</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/sema4_demo.ewp</path></project></workspace>
