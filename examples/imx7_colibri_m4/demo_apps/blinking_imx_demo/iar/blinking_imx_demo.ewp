# IAR project blinking_imx_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __DEBUG; CPU_IMX7D_M4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MCIMX7D/include; ../../../../../platform/devices/MCIMX7D/startup; ../../../../../platform/drivers/inc; ../../../../../rtos/FreeRTOS/Source/include; ../../../../../platform/utilities/inc; ../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __DEBUG
  AARM.AUserIncludes: ../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../..
  OBJCOPY.OOCOutputFile: 1
  ILINK.IlinkOutputFile: blinking_imx_demo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x200
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MCIMX7D/linker/iar/MCIMX7D_M4_tcm.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __NDEBUG; CPU_IMX7D_M4
  ICCARM.CCOptLevel: 3
  group freertos
    ../../../../../rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
    ../../../../../rtos/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../rtos/FreeRTOS/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group startup
    ../../../../../platform/devices/MCIMX7D/startup/iar/: startup_MCIMX7D_M4.s
    ../../../../../platform/devices/MCIMX7D/startup/: system_MCIMX7D_M4.c system_MCIMX7D_M4.h
  group board
    ../../../: FreeRTOSConfig.h pin_mux.c pin_mux.h board.c board.h clock_freq.c clock_freq.h gpio_pins.c gpio_pins.h
    ../: hardware_init.c
  group source
    ../: main.c gpt_timer.c gpt_timer.h gpio_ctrl.c gpio_ctrl.h
  group driver
    ../../../../../platform/drivers/src/: gpio_imx.c gpt.c rdc_semaphore.c uart_imx.c
    ../../../../../platform/drivers/inc/: gpio_imx.h gpt.h rdc_semaphore.h uart_imx.h
  group system
    ../../../../../platform/drivers/inc/: ccm_analog_imx7d.h ccm_imx7d.h rdc.h rdc_defs_imx7d.h wdog_imx.h
    ../../../../../platform/drivers/src/: ccm_analog_imx7d.c ccm_imx7d.c rdc.c wdog_imx.c
  group utilities
    ../../../../../platform/utilities/src/: debug_console_imx.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: debug_console_imx.h
