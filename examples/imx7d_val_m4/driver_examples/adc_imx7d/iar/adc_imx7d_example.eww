<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>adc_imx7d_example</project><configuration>Release</configuration></member><member><project>adc_imx7d_example</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>adc_imx7d_example</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>adc_imx7d_example</project><configuration>Debug</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/adc_imx7d_example.ewp</path></project></workspace>
